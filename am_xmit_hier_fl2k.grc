<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>am_xmit_multi_carrier_fl2k</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_sample_rate</value></param>
<param><key>value</key><value>8192e3</value></param>
</block>
<block>
<key>AM_Modulator</key>
<param><key>id</key><value>AM_Modulator_0</value></param>
<param><key>af_sample_rate</key><value>16000</value></param>
<param><key>carrier_freq</key><value>530e3</value></param>
<param><key>fgain</key><value>128</value></param>
<param><key>fir_interp</key><value>512</value></param>
<param><key>rf_sample_rate</key><value>8192000</value></param>
<param><key>filename</key><value>"/home/chuck/otr/JackBenny/wav/pgm1"</value></param>
</block>
<block>
<key>AM_Modulator</key>
<param><key>id</key><value>AM_Modulator_1</value></param>
<param><key>af_sample_rate</key><value>16000</value></param>
<param><key>carrier_freq</key><value>540e3</value></param>
<param><key>fgain</key><value>128</value></param>
<param><key>fir_interp</key><value>512</value></param>
<param><key>rf_sample_rate</key><value>8192000</value></param>
<param><key>filename</key><value>"/home/chuck/otr/JackBenny/wav/pgm2"</value></param>
</block>
<block>
<key>AM_Modulator</key>
<param><key>id</key><value>AM_Modulator_2</value></param>
<param><key>af_sample_rate</key><value>16000</value></param>
<param><key>carrier_freq</key><value>550e3</value></param>
<param><key>fgain</key><value>128</value></param>
<param><key>fir_interp</key><value>512</value></param>
<param><key>rf_sample_rate</key><value>8192000</value></param>
<param><key>filename</key><value>"/home/chuck/otr/JackBenny/wav/pgm3"</value></param>
</block>
<block>
<key>AM_Modulator</key>
<param><key>id</key><value>AM_Modulator_3</value></param>
<param><key>af_sample_rate</key><value>16000</value></param>
<param><key>carrier_freq</key><value>560e3</value></param>
<param><key>fgain</key><value>128</value></param>
<param><key>fir_interp</key><value>512</value></param>
<param><key>rf_sample_rate</key><value>8192000</value></param>
<param><key>filename</key><value>"/home/chuck/otr/JackBenny/wav/pgm4"</value></param>
</block>
<block>
<key>AM_Modulator</key>
<param><key>id</key><value>AM_Modulator_4</value></param>
<param><key>af_sample_rate</key><value>16000</value></param>
<param><key>carrier_freq</key><value>570e3</value></param>
<param><key>fgain</key><value>128</value></param>
<param><key>fir_interp</key><value>512</value></param>
<param><key>rf_sample_rate</key><value>8192000</value></param>
<param><key>filename</key><value>"/home/chuck/otr/JackBenny/wav/pgm5"</value></param>
</block>
<block>
<key>AM_Modulator</key>
<param><key>id</key><value>AM_Modulator_5</value></param>
<param><key>af_sample_rate</key><value>16000</value></param>
<param><key>carrier_freq</key><value>590e3</value></param>
<param><key>fgain</key><value>128</value></param>
<param><key>fir_interp</key><value>512</value></param>
<param><key>rf_sample_rate</key><value>8192000</value></param>
<param><key>filename</key><value>"/home/chuck/otr/JackBenny/wav/pgm6"</value></param>
</block>
<block>
<key>AM_Modulator</key>
<param><key>id</key><value>AM_Modulator_6</value></param>
<param><key>af_sample_rate</key><value>16000</value></param>
<param><key>carrier_freq</key><value>600e3</value></param>
<param><key>fgain</key><value>128</value></param>
<param><key>fir_interp</key><value>512</value></param>
<param><key>rf_sample_rate</key><value>8192000</value></param>
<param><key>filename</key><value>"/home/chuck/otr/JackBenny/wav/pgm7"</value></param>
</block>
<block>
<key>AM_Modulator</key>
<param><key>id</key><value>AM_Modulator_7</value></param>
<param><key>af_sample_rate</key><value>16000</value></param>
<param><key>carrier_freq</key><value>610e3</value></param>
<param><key>fgain</key><value>128</value></param>
<param><key>fir_interp</key><value>512</value></param>
<param><key>rf_sample_rate</key><value>8192000</value></param>
<param><key>filename</key><value>"/home/chuck/otr/JackBenny/wav/pgm8"</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>8</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/root/am_xmit_console_fl2k.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>128</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_6</value></param>
<param><key>const</key><value>.13</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>rf_sample_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>rf_sample_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>AM_Modulator_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AM_Modulator_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>AM_Modulator_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>AM_Modulator_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>AM_Modulator_4</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>AM_Modulator_5</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>AM_Modulator_6</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>AM_Modulator_7</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_6</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_6</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_6</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
